require ${@bb.utils.contains('AGL_FEATURES', 'agl-drm-lease', 'linux-renesas_agl-drm-lease.inc', '', d)}
