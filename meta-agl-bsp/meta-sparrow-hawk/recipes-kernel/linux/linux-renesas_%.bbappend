require recipes-kernel/linux/linux-yocto-agl.inc
