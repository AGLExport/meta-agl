RDEPENDS:${PN}:append = " wayland-wsegl"
