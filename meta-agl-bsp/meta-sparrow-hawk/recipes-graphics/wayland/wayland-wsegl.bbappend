DEPENDS:append = " wayland-protocols"
