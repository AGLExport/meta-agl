DESCRIPTION = "Virtual gles-module"

LICENSE = "GPL-2.0-only"

DEPENDS = "user-module-gles wayland-kms libgbm"

PROVIDES = "virtual/libgles2 virtual/egl"
